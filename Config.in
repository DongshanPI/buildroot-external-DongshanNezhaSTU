## Config.in
```kconfig
source "$BR2_EXTERNAL_AWOL_PATH/package/lvgl-desktop/Config.in"
source "$BR2_EXTERNAL_AWOL_PATH/package/myir-hmi-gui/Config.in"
```
